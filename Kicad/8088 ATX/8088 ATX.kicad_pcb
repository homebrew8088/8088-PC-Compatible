# Repository homebrew8088/8088-PC-Compatible (continued)

## KiCad design Kicad/V40 ISA/V40.kicad_pcb

Parts:
C1, C2, C3, C4: 0.1uF; C_Disc_D4.3mm_W1.9mm_P5.00mm
J1: Conn_02x08_Counter_Clockwise; 16_EDGE_CARD_BUS
J9: Bus_ISA_8bit; BUS_8_BIT
R1, R2: 10K ohm; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
U1: 70208; PLCC-68_THT-Socket
U2, U3: 74LS573; DIP-20_W7.62mm
U4: 74LS245; DIP-20_W7.62mm
Y1: Crystal; Crystal_HC18-U_Vertical

Connections:
/5+: C1.2, C2.2, C3.2, C4.2, J9.3 (VCC), J9.29 (VCC), R1.2, U1.1 (VDD), U2.20 (VCC), U3.20 (VCC), U4.20 (VCC)
/5-: J9.5 (-5V)
/12+: J9.9 (+12V)
/12-: J9.7 (-12V)
/A0: J9.62 (BA00), U2.12 (Q7)
/A1: J9.61 (BA01), U2.13 (Q6)
/A2: J9.60 (BA02), U2.14 (Q5)
/A3: J9.59 (BA03), U2.15 (Q4)
/A4: J9.58 (BA04), U2.16 (Q3)
/A5: J9.57 (BA05), U2.17 (Q2)
/A6: J9.56 (BA06), U2.18 (Q1)
/A7: J9.55 (BA07), U2.19 (Q0)
/A8: J9.54 (BA08), U1.17 (A8)
/A9: J9.53 (BA09), U1.16 (A9)
/A10: J9.52 (BA10), U1.15 (A10)
/A11: J9.51 (BA11), U1.14 (A11)
/A12: J9.50 (BA12), U1.13 (A12)
/A13: J9.49 (BA13), U1.12 (A13)
/A14: J9.48 (BA14), U1.11 (A14)
/A15: J9.47 (BA15), U1.10 (A15)
/A16: J9.46 (BA16), U3.16 (Q3)
/A16_: U1.9 (A16), U3.5 (D3)
/A17: J9.45 (BA17), U3.17 (Q2)
/A17_: U1.8 (A17), U3.4 (D2)
/A18: J9.44 (BA18), U3.18 (Q1)
/A18_: U1.7 (A18), U3.3 (D1)
/A19: J9.43 (BA19), U3.19 (Q0)
/A19_: U1.6 (A19), U3.2 (D0)
/AD0: U1.26 (AD0), U2.9 (D7), U4.9 (A7)
/AD1: U1.25 (AD1), U2.8 (D6), U4.8 (A6)
/AD2: U1.24 (AD2), U2.7 (D5), U4.7 (A5)
/AD3: U1.23 (AD3), U2.6 (D4), U4.6 (A4)
/AD4: U1.22 (AD4), U2.5 (D3), U4.5 (A3)
/AD5: U1.21 (AD5), U2.4 (D2), U4.4 (A2)
/AD6: U1.20 (AD6), U2.3 (D1), U4.3 (A1)
/AD7: U1.19 (AD7), U2.2 (D0), U4.2 (A0)
/AEN: J9.42 (AEN)
/ALE: J9.28 (ALE), U1.50 (ASTB), U2.11 (Load), U3.11 (Load)
/CH_CK: J9.32 (IO)
/CLK88: J9.20 (CLK)
/D0: J9.40 (DB0), U4.11 (B7)
/D1: J9.39 (DB1), U4.12 (B6)
/D2: J9.38 (DB2), U4.13 (B5)
/D3: J9.37 (DB3), U4.14 (B4)
/D4: J9.36 (DB4), U4.15 (B3)
/D5: J9.35 (DB5), U4.16 (B2)
/D6: J9.34 (DB6), U4.17 (B1)
/D7: J9.33 (DB7), U4.18 (B0)
/DACK1: J9.17 (~DACK1)
/DACK2: J9.26 (~DACK2)
/DACK3: J9.15 (~DACK3)
/DEN: R1.1, U1.56 (BUFFEN), U4.19 (CE)
/DRQ0: J1.12, U1.36 (INTAK/SRDY/TOUT1)
/DRQ1: J9.18 (DRQ1)
/DRQ2: J9.6 (DRQ2)
/DRQ3: J9.16 (DRQ3)
/DTR: U1.57 (BUFR/W), U4.1 (A->B)
/GND: C1.1, C2.1, C3.1, C4.1, J9.1 (GND), J9.10 (GND), J9.31 (GND), R2.1, U1.18 (GND), U1.52 (GND), U2.10 (GND), U3.10 (GND), U4.10 (GND); also elsewhere on the board
/HF_PCLK: J1.11, U1.44 (TCLK)
/HOLD: J1.14, U1.4 (HLDRQ)
/HOLDA: J1.13, U1.3 (HLDAK), U2.1 (OE), U3.1 (OE)
/IORD: J9.14 (~IOR), U1.61 (IORD)
/IOWR: J9.13 (~IOW), U1.59 (IOWR)
/IO_000X: J1.2
/IO_002X: J1.3
/IO_004X: J1.4
/IO_006X: J1.5
/IO_008X: J1.6
/IRQ1: J1.1, U1.37 (INTP1)
/IRQ2: J9.4 (IRQ2), U1.38 (INTP2)
/IRQ3: J9.25 (IRQ3), U1.39 (INTP3)
/IRQ4: J9.24 (IRQ4), U1.40 (INTP4)
/IRQ5: J9.23 (IRQ5), U1.41 (INTP5)
/IRQ6: J9.22 (IRQ6), U1.42 (INTP6)
/IRQ7: J9.21 (IRQ7), U1.43 (INTP7)
/MRD: J9.12 (~SMEMR), U1.62 (MRD)
/MWR: J9.11 (~SMEMW), U1.60 (MWR)
/NC: J9.8 (UNUSED)
/NMI: J1.8, U1.66 (NMI)
/OSC88: J9.30 (OSC)
/POLL: R2.2, U1.47 (POLL)
/RDY1: J9.41 (IO_READY), U1.67 (READY)
/READY: J1.15
/REFRQ: J9.19 (~DACK0)
/RESET: J1.16, U1.68 (RESET)
/RESOUT: J9.2 (RESET)
/SPK_GO: J1.10, U1.46 (TCTL2)
/SPK_OUT: J1.9, U1.45 (TOUT2)
/TC: J9.27 (TC)
/X1: U1.54 (X1), Y1.2
/X2: U1.53 (X2), Y1.1

Board: 2 copper layers, 132.0 x 73.9 mm, 15 parts (0 on the bottom side), 68 nets.

Other parts of the board:
R: L; Large_Via
R#2: L; Large_Via

Their connections:
/GND: R.1; also elsewhere on the board

## KiCad design Kicad/CH376S Module/CH376S Module.kicad_pcb

Parts:
C1: 0.47uF; C_Disc_D4.3mm_W1.9mm_P5.00mm
C2: 10nF; C_Disc_D4.3mm_W1.9mm_P5.00mm
C3: 10uF; C_Disc_D4.3mm_W1.9mm_P5.00mm
C4, C5: 22pF; C_Disc_D4.3mm_W1.9mm_P5.00mm
C6, C7: 0.1uF; C_Disc_D4.3mm_W1.9mm_P5.00mm
D1: LED; LED_D3.0mm
P1: HEADER; PinHeader_2x08_P2.54mm_Vertical
R2: 1K ohm; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
U1: CH376; SOIC-28W_7.5x17.9mm_P1.27mm
U2: LM1117-3.3; TO-220-3_Horizontal_TabDown
USB1: Conn_01x04; USB_A_CONNFLY_DS1095-WNR0
Y2: 12 MHz; Crystal_HC18-U_Vertical

Connections:
/3v3: C1.1, C7.1, D1.2 (A), U1.28, U2.2 (VO)
/5+: C6.1, P1.6, U2.3 (VI), USB1.1
/A0: P1.10, U1.8
/CS: P1.12, U1.27
/D0: P1.1, U1.15
/D1: P1.3, U1.16
/D2: P1.5, U1.17
/D3: P1.7, U1.18
/D4: P1.9, U1.19
/D5: P1.11, U1.20
/D6: P1.13, U1.21
/D7: P1.15, U1.22
/D+: U1.10, USB1.3
/D-: U1.11, USB1.2
/GND: C2.2, C4.2, C5.2, C6.2, C7.2, P1.2, P1.4, U1.5, U1.12, U1.23, U2.1 (GND), USB1.4
/INT: P1.8, U1.1
/LED: D1.1 (K), R2.1
/LED_PIN: R2.2, U1.24
/PIN_9: C2.1, U1.9
/RD: P1.14, U1.4
/RST: C1.2, U1.2
/WR: P1.16, U1.3
/XI: C4.1, U1.13, Y2.1
/XO: C5.1, U1.14, Y2.2

Board: 2 copper layers, 52.1 x 29.0 mm, 13 parts (0 on the bottom side), 24 nets.

## KiCad design Kicad/8088 ISA/8088.kicad_pcb

Board: 2 copper layers, 132.0 x 73.9 mm, 26 parts (0 on the bottom side), 80 nets.

Parts:
C1, C2, C3, C4, C5, C6, C7, C8: 0.1uF; C_Disc_D4.3mm_W1.9mm_P5.00mm
J1: Conn_02x08_Counter_Clockwise; 16_EDGE_CARD_BUS
J9: Bus_ISA_8bit; BUS_8_BIT
R: L; Large_Via
R1: 27 ohm; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R2, R3: 510 ohm; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R4, R5: 10K ohm; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R#2: L; Large_Via
U1: 8088; DIP-40_W15.24mm
U2, U3: 74LS573; DIP-20_W7.62mm
U4: 74LS245; DIP-20_W7.62mm
U5: 74LS257; DIP-16_W7.62mm
U6: 8284; DIP-18_W7.62mm
U7: 8259; DIP-28_W15.24mm
U8: 8253; DIP-24_W15.24mm
Y1: Crystal; Crystal_HC18-U_Vertical

Connections:
/5+: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, J9.3, J9.29, R4.2, R5.2, U1.33, U1.40, U2.20, U3.20, U4.20, U5.16, U6.7, U6.18, U7.16, U7.28, U8.11, U8.14, U8.24
/A0: J9.62, U3.12, U7.27, U8.19
/A1: J9.61, U3.13, U8.20
/A2: J9.60, U3.14
/A3: J9.59, U3.15
/A4: J9.58, U3.16
/A5: J9.57, U3.17
/A6: J9.56, U3.18
/A7: J9.55, U3.19
/A8: J9.54, U1.8
/A9: J9.53, U1.7
/A10: J9.52, U1.6
/A11: J9.51, U1.5
/A12: J9.50, U1.4
/A13: J9.49, U1.3
/A14: J9.48, U1.2
/A15: J9.47, U1.39
/A16: J9.46, U2.16
/A16_: U1.38, U2.5
/A17: J9.45, U2.17
/A17_: U1.37, U2.4
/A18: J9.44, U2.18
/A18_: U1.36, U2.3
/A19: J9.43, U2.19
/A19_: U1.35, U2.2
/AD0: U1.16, U3.9, U4.9
/AD1: U1.15, U3.8, U4.8
/AD2: U1.14, U3.7, U4.7
/AD3: U1.13, U3.6, U4.6
/AD4: U1.12, U3.5, U4.5
/AD5: U1.11, U3.4, U4.4
/AD6: U1.10, U3.3, U4.3
/AD7: U1.9, U3.2, U4.2
/ALE: J9.28, U1.25, U2.11, U3.11
/CLK1: R1.2, U6.8
/CLK_88: R1.1, U1.19
/D0: J9.40, U4.11, U7.11, U8.8
/D1: J9.39, U4.12, U7.10, U8.7
/D2: J9.38, U4.13, U7.9, U8.6
/D3: J9.37, U4.14, U7.8, U8.5
/D4: J9.36, U4.15, U7.7, U8.4
/D5: J9.35, U4.16, U7.6, U8.3
/D6: J9.34, U4.17, U7.5, U8.2
/D7: J9.33, U4.18, U7.4, U8.1
/DEN: R5.1, U1.26, U4.19
/DRQ0: J1.12, U8.13
/DTR: U1.27, U4.1
/GND: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, J9.1, J9.10, J9.31, R.1, R2.2, R3.2, R#2.1, U1.1, U1.20, U1.23, U2.10, U3.10, U4.10, U5.8, U6.1, U6.3, U6.6, U6.9, U6.13, U6.15, U7.14, U8.12
/HF_PCLK: J1.11, U8.9, U8.15, U8.18
/HOLD: J1.14, U1.31
/HOLDA: J1.13, U1.30, U2.1, U3.1, U5.15
/INTA: U1.24, U7.26
/INTR: U1.18, U7.17
/IORD: J9.14, U5.7, U7.3, U8.22
/IOWR: J9.13, U5.12, U7.2, U8.23
/IO_002X: J1.3, U7.1
/IO_004X: J1.4, U8.21
/IO_M: U1.28, U5.1
/IRQ0: U7.18, U8.10
/IRQ1: J1.1, U7.19
/IRQ2: J9.4, U7.20
/IRQ3: J9.25, U7.21
/IRQ4: J9.24, U7.22
/IRQ5: J9.23, U7.23
/IRQ6: J9.22, U7.24
/IRQ7: J9.21, U7.25
/MRD: J9.12, U5.4
/MWR: J9.11, U5.9
/NMI: J1.8, U1.17
/PU1: R4.1, U5.3, U5.5, U5.10, U5.14
/RD: U1.32, U5.2, U5.6
/RDY1: J9.41, U6.4
/READY1: U1.22, U6.5
/RESET: J1.16, U6.11
/RESET1: U1.21, U6.10
/SPK_GO: J1.10, U8.16
/SPK_OUT: J1.9, U8.17
/WR: U1.29, U5.11, U5.13
/X1: R2.1, U6.17, Y1.2
/X2: R3.1, U6.16, Y1.1

## KiCad design Kicad/Other PCBs/LCD 8255/LCD 8255.kicad_pcb

Board: 2 copper layers, 114.3 x 83.8 mm, 13 parts (0 on the bottom side), 44 nets.

Parts:
C1, C2, C3, C4: 0.1uF; C_Disc_D4.3mm_W1.9mm_P5.00mm
J1: Bus_ISA_8bit; BUS_8_BIT
J2: Conn_01x16; PinHeader_1x16_P2.54mm_Vertical
R: L; Large_Via
R#2: L; Large_Via
RV1: R_POT; Potentiometer_Piher_PT-6-V_Vertical
U1, U2, U3: 74LS138; DIP-16_W7.62mm
U4: 8255; DIP-40_W15.24mm

Connections:
/0X0XXX: U1.15, U2.5
/0X04XX: U2.11, U3.5
/0X044X: U3.13, U4.6
/5+: C1.2, C2.2, C3.2, C4.2, J1.3, J1.29, J2.2, J2.15, RV1.3, U1.6, U1.16, U2.6, U2.16, U3.6, U3.16, U4.26
/A0: J1.62, U4.9
/A1: J1.61, U4.8
/A4: J1.58, U3.4
/A5: J1.57, U3.1
/A6: J1.56, U3.2
/A7: J1.55, U3.3
/A8: J1.54, U2.1
/A9: J1.53, U2.2
/A10: J1.52, U2.3
/A11: J1.51, U2.4
/A12: J1.50, U1.1
/A13: J1.49, U1.2
/A14: J1.48, U1.3
/A15: J1.47, U1.4
/ACKA: U4.11, U4.23
/CONTRAST: J2.3, RV1.2
/D0: J1.40, U4.34
/D1: J1.39, U4.33
/D2: J1.38, U4.32
/D3: J1.37, U4.31
/D4: J1.36, U4.30
/D5: J1.35, U4.29
/D6: J1.34, U4.28
/D7: J1.33, U4.27
/GND: C1.1, C2.1, C3.1, C4.1, J1.1, J1.10, J1.31, J2.1, J2.16, R.1, RV1.1, U1.5, U1.8, U2.8, U3.8, U4.7
/IORD: J1.14, U4.5
/IOWR: J1.13, U4.36
/LCD_EN: J2.6, U4.18
/LCD_RS: J2.4, U4.20
/LCD_RW: J2.5, U4.19
/PA0: J2.7, U4.4
/PA1: J2.8, U4.3
/PA2: J2.9, U4.2
/PA3: J2.10, U4.1
/PA4: J2.11, U4.40
/PA5: J2.12, U4.39
/PA6: J2.13, U4.38
/PA7: J2.14, U4.37
/RESET: J1.2, U4.35
/STBA: U4.13, U4.22

## Commit log

2021-11-05 moved keyboard code
2021-11-05 Renamed sub
2021-11-05 Added asm
2021-11-05 upload raw bios code
2021-11-08 update
    update from Raspberry PI files.
2021-11-10 Fixed original files
    Most important add back in jump code to bios.asm
2021-11-10 updated and verified bios.bin works on 8088
2021-11-11 Added Some DOS Files
2021-11-14 Added CH376 label
2021-11-16 Added Parts Lists
2021-11-16 Fixed directory names to be more friendly with Linux
2021-11-16 Added working network files
2021-11-16 Updated Network Drivers
2021-11-17 Deleted Files
2021-11-20 Updated 80188 Schematic
2021-11-20 Added 80188 BIOS
2022-01-04 Added KICAD files
2022-01-08 fixed 5+ pin on PCB
2022-01-28 Updated Kicad files
2022-03-14 Added 640k Ram Card
2022-03-24 Added MS Mouse 5.0
2022-03-24 Update to DMA card
2022-03-24 Updated Gerber files
2022-03-26 DMA update
2022-03-26 Gerber update
2022-03-28 Added port 0x61 read to 4 slot main board
2022-03-29 4 Slot Main board update
2022-04-01 Updated 640k Gerber files
2022-04-03 640k update
2022-04-04 Updated DMA card
2022-04-05 update 8088 card
2022-04-09 Update main board
2022-04-16 Updated Schematics
2022-04-25 Added LCD ISA card
2022-05-04 Added universal BIOS
2022-05-05 Updated BIOS name
2022-05-24 Added 10 Slot main board
2022-05-28 Update Gerber files
2022-06-13 Added CH376 Module
2022-06-28 Added 386EX prototype
2022-06-28 Added Checkit
2022-06-29 Added Basic86
2022-07-06 updates to 386
2022-07-20 update label on 80188
2022-07-22 added 8088 card with ZIF socket
2022-07-24 add 64k ROM card
2022-09-13 Added 8088 Max mode
2022-09-16 update 8088 max
2022-11-03 Added PCB's
2023-01-02 updated DMA
    Added DMA controller to main board.
2023-01-17 Update fp-info-cache
2023-02-14 Added Files
2023-02-17 Updated Gerber's
2023-02-21 ADDED Port
2023-03-28 added no video bios
2024-05-23 moved files
