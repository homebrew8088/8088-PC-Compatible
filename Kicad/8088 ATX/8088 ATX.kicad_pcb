# Repository homebrew8088/8088-PC-Compatible

File README.md:

# 8088-PC-Compatible
8088 PC Compatible

\
\
This is a repository for my 8088 PC Compatible project developed in 2021. The Motherboard is built to be generally PC XT compatible.

**Homepage**\
https://www.homebrew8088.com/

**Join the discussion group on Discord**\
https://discord.gg/AswNqwpRGP

**eBay store**\
http://www.ebay.com/sch/emil6190/m.html

**Features:**\
-8088, NEC V20, OR NEC V40 Processor\
-512k RAM (This can be changed)\
-8 Bit ISA sockets (4 slots or 7 slots)\
-PC Speaker\
-USB "Hard Drive"\
-PS/2 Keyboard\
-ATX form factor\
-Add on DMA controller (7 slot ISA only) 

[My BIOS Files](https://github.com/homebrew8088/8088-PC-Compatible/tree/main/bios) are early versions and are very primitive.

The best BIOS to use is located at https://gitlab.com/hakfoo1/v40-bios. This works on the V20 and V40 just fine. You will need one of the earlier version if you are using an actual 8088 processor. This is due to some 80186 code that was included.

-note this BIOS will not boot without a video card.

You will find the [Keyboard Fix](https://github.com/homebrew8088/8088-PC-Compatible/tree/main/asm/keyboard%20fix) under asm. Add this to your autoexec.bat if your keyboard is not working after DOS boots up.

## KiCad design Kicad/8088 ATX/8088 ATX.kicad_pcb

Schematic: 8088 ATX.sch

Parts:
8x8mm1: PWR SW; 6 PIN DTDP
ATXPOWER1: Conn_02x12_Top_Bottom; 24_PIN_ATX_POWER
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C16, C17, C18, C19, C22, C23, C24, C25, C26, C27, C28, C29, C63, C64, C65, C101, C102, C103, C104, C105, C106, C107, C108, C201, C202, C203, C204, C205, C206: 0.1uF; C_Disc_D4.3mm_W1.9mm_P5.00mm
CH376: PORT 0XE0; PinHeader_2x08_P2.54mm_Vertical
D1: POWER; LED_D3.0mm
J2: Mini-DIN-6; 6_PIN_DIN
J3: SPK; PinHeader_1x04_P2.54mm_Vertical
J6: PWR ON; PinHeader_1x02_P2.54mm_Vertical
J9: Bus_ISA_8bit; BUS_8_BIT_SMALL_PADS
J10: Conn_02x08_Counter_Clockwise; 2x08_PIN_EDGE_CARD
J12: RESET; PinHeader_1x02_P2.54mm_Vertical
R1, R2, R4, R102, R103: 510 ohm; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R3, R14, R17, R18, R63, R101: 27 ohm; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R5, R6, R7, R8, R9, R12, R13, R61, R62: 10k ohm; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R104, R105: 10K ohm; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
RN1, RN3: 10k ohm; R_Array_SIP4
RN2: 10K ohm; R_Array_SIP9
SW1: RESET; SW_PUSH_6mm
SW2: DRQ0/DACK0 EN; SW_DIP_SPSTx02_Slide_9.78x7.26mm_W7.62mm_P2.54mm
U1, U17, U117, U205: 74LS139; DIP-16_W7.62mm
U2, U104: 74LS245; DIP-20_W7.62mm
U3: 33 ohm; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
U9, U12, U13, U206: 74LS138; DIP-16_W7.62mm
U11, U106: 8284; DIP-18_W7.62mm
U14: 74LS74; DIP-14_W7.62mm
U15, U65, U102, U103: 74LS573; DIP-20_W7.62mm
U16, U63: 74LS04; DIP-14_W7.62mm
U19: 82C42; PLCC-44_THT-Socket
U20: 74LS07; DIP-14_W7.62mm
U61: 8237; DIP-40_W15.24mm
U64: 74LS670; DIP-16_W7.62mm
U101: 8088; DIP-40_W15.24mm
U105: 74LS257; DIP-16_W7.62mm
U107: 8259; DIP-28_W15.24mm
U108: 8253; DIP-24_W15.24mm
U201, U202: 64K; DIP-32_W15.24mm
U203: AS6C1008; DIP-32_W15.24mm
U204: AS6C4008; DIP-32_W15.24mm
Y2: 14.31818 MHz; Crystal_HC18-U_Vertical
Y101: Crystal; Crystal_HC18-U_Vertical

Connections:
/5-: J9.5 (-5V)
/12+: ATXPOWER1.10, J9.9 (+12V)
/12-: ATXPOWER1.14, J9.7 (-12V)
/64K_ROM_CS: U201.22 (CE), U206.7 (O7)
/128K_CS: U203.22 (~CS1), U205.12 (O0)
/512K_CS: U204.22 (CE#), U205.4 (O0)
/760_EN: U64.12 (~Ew), U117.4 (O0)
/A0: J9.62 (BA00), U17.14 (A0), U61.32 (A0), U64.14 (Wa), U103.12 (Q7), U107.27 (A0), U108.19 (A0), U201.12 (A0), U202.12 (A0), U203.12 (A0), U204.12 (A0)
/A1: J9.61 (BA01), U17.13 (A1), U61.33 (A1), U64.13 (Wb), U103.13 (Q6), U108.20 (A1), U201.11 (A1), U202.11 (A1), U203.11 (A1), U204.11 (A1)
/A2: CH376.8, J9.60 (BA02), U19.10 (A2), U61.34 (A2), U103.14 (Q5), U201.10 (A2), U202.10 (A2), U203.10 (A2), U204.10 (A2)
/A3: J9.59 (BA03), U61.35 (A3), U103.15 (Q4), U201.9 (A3), U202.9 (A3), U203.9 (A3), U204.9 (A3)
/A4: J9.58 (BA04), U13.4 (E1), U61.37 (A4), U103.16 (Q3), U201.8 (A4), U202.8 (A4), U203.8 (A4), U204.8 (A4)
/A5: J9.57 (BA05), U13.1 (A0), U61.38 (A5), U103.17 (Q2), U201.7 (A5), U202.7 (A5), U203.7 (A5), U204.7 (A5)
/A6: J9.56 (BA06), U13.2 (A1), U61.39 (A6), U103.18 (Q1), U201.6 (A6), U202.6 (A6), U203.6 (A6), U204.6 (A6)
/A7: J9.55 (BA07), U13.3 (A2), U61.40 (A7), U103.19 (Q0), U201.5 (A7), U202.5 (A7), U203.5 (A7), U204.5 (A7)
/A8: J9.54 (BA08), U12.1 (A0), U65.12 (Q7), U101.8 (A8), U201.27 (A8), U202.27 (A8), U203.27 (A8), U204.27 (A8)
/A9: J9.53 (BA09), U12.2 (A1), U65.13 (Q6), U101.7 (A9), U201.26 (A9), U202.26 (A9), U203.26 (A9), U204.26 (A9)
/A10: J9.52 (BA10), U12.3 (A2), U65.14 (Q5), U101.6 (A10), U201.23 (A10), U202.23 (A10), U203.23 (A10), U204.23 (A10)
/A11: J9.51 (BA11), U12.4 (E1), U65.15 (Q4), U101.5 (A11), U201.25 (A11), U202.25 (A11), U203.25 (A11), U204.25 (A11)
/A12: J9.50 (BA12), U9.1 (A0), U65.16 (Q3), U101.4 (A12), U201.4 (A12), U202.4 (A12), U203.4 (A12), U204.4 (A12)
/A13: J9.49 (BA13), U9.2 (A1), U65.17 (Q2), U101.3 (A13), U201.28 (A13), U202.28 (A13), U203.28 (A13), U204.28 (A13)
/A14: J9.48 (BA14), U9.3 (A2), U65.18 (Q1), U101.2 (A14), U201.29 (A14), U202.29 (A14), U203.3 (A14), U204.3 (A14)
/A15: J9.47 (BA15), U9.4 (E1), U65.19 (Q0), U101.39 (A15), U201.3 (A15), U202.3 (A15), U203.31 (A15), U204.31 (A15)
/A16: J9.46 (BA16), U64.10 (Q1), U102.16 (Q3), U203.2 (A16), U204.2 (A16), U206.1 (A0)
/A16_: U101.38 (A16/S3), U102.5 (D3)
/A17: J9.45 (BA17), U64.9 (Q2), U102.17 (Q2), U204.30 (A17), U205.14 (A0), U206.2 (A1)
/A17_: U101.37 (A17/S4), U102.4 (D2)
/A18: J9.44 (BA18), U64.7 (Q3), U102.18 (Q1), U204.1 (A18), U205.13 (A1), U206.3 (A2)
/A18_: U101.36 (A18/S5), U102.3 (D1)
/A19: J9.43 (BA19), U64.6 (Q4), U102.19 (Q0), U205.2 (A0)
/A19_: U101.35 (A19/S6), U102.2 (D0)
/AD0: U101.16 (AD0), U103.9 (D7), U104.9 (A7)
/AD1: U101.15 (AD1), U103.8 (D6), U104.8 (A6)
/AD2: U101.14 (AD2), U103.7 (D5), U104.7 (A5)
/AD3: U101.13 (AD3), U103.6 (D4), U104.6 (A4)
/AD4: U101.12 (AD4), U103.5 (D3), U104.5 (A3)
/AD5: U101.11 (AD5), U103.4 (D2), U104.4 (A2)
/AD6: U101.10 (AD6), U103.3 (D1), U104.3 (A1)
/AD7: U101.9 (AD7), U103.2 (D0), U104.2 (A0)
/ADSTB: U61.8 (ADSTB), U65.11 (Load)
/AEN: J9.42 (AEN), R12.2, U61.9 (AEN), U63.3
/AEN_OE: U63.4, U64.11 (~Er), U65.1 (OE)
/ALE: J9.28 (ALE), U101.25 (ALE), U102.11 (Load), U103.11 (Load)
/CH_CK: J9.32 (IO), R7.2, U17.2 (A0)
/CLK: R18.2, R63.2, U11.8 (CLK)
/CLK1: R101.2, U106.8 (CLK)
/CLK88: J9.20 (CLK), R18.1
/CLK88_1: R63.1, U61.12 (CLK)
/CLK_88: R101.1, U101.19 (CLK)
/D0: CH376.15, J9.40 (DB0), U2.9 (A7), U15.9 (D7), U19.14 (D0), U61.30 (DB0), U64.15 (D1), U65.9 (D7), U104.11 (B7), U107.11 (D0), U108.8 (D0), U201.13 (D0), U202.13 (D0), U203.13 (Q0), U204.13 (DQ0)
/D1: CH376.13, J9.39 (DB1), U2.8 (A6), U15.8 (D6), U19.15 (D1), U61.29 (DB1), U64.1 (D2), U65.8 (D6), U104.12 (B6), U107.10 (D1), U108.7 (D1), U201.14 (D1), U202.14 (D1), U203.14 (Q1), U204.14 (DQ1)
/D2: CH376.11, J9.38 (DB2), U2.7 (A5), U15.7 (D5), U19.16 (D2), U61.28 (DB2), U64.2 (D3), U65.7 (D5), U104.13 (B5), U107.9 (D2), U108.6 (D2), U201.15 (D2), U202.15 (D2), U203.15 (Q2), U204.15 (DQ2)
/D3: CH376.9, J9.37 (DB3), U2.6 (A4), U15.6 (D4), U19.17 (D3), U61.27 (DB3), U64.3 (D4), U65.6 (D4), U104.14 (B4), U107.8 (D3), U108.5 (D3), U201.17 (D3), U202.17 (D3), U203.17 (Q3), U204.17 (DQ3)
/D4: CH376.7, J9.36 (DB4), U2.5 (A3), U15.5 (D3), U19.18 (D4), U61.26 (DB4), U65.5 (D3), U104.15 (B3), U107.7 (D4), U108.4 (D4), U201.18 (D4), U202.18 (D4), U203.18 (Q4), U204.18 (DQ4)
/D5: CH376.5, J9.35 (DB5), U2.4 (A2), U15.4 (D2), U19.19 (D5), U61.23 (DB5), U65.4 (D2), U104.16 (B2), U107.6 (D5), U108.3 (D5), U201.19 (D5), U202.19 (D5), U203.19 (Q5), U204.19 (DQ5)
/D6: CH376.3, J9.34 (DB6), U2.3 (A1), U15.3 (D1), U19.20 (D6), U61.22 (DB6), U65.3 (D1), U104.17 (B1), U107.5 (D6), U108.2 (D6), U201.20 (D6), U202.20 (D6), U203.20 (Q6), U204.20 (DQ6)
/D7: CH376.1, J9.33 (DB7), U2.2 (A0), U15.2 (D0), U19.21 (D7), U61.21 (DB7), U65.2 (D0), U104.18 (B0), U107.4 (D7), U108.1 (D7), U201.21 (D7), U202.21 (D7), U203.21 (Q7), U204.21 (DQ7)
/DACK0: SW2.2, U61.25 (DACK0)
/DACK1: J9.17 (~DACK1), RN2.7 (R6), U61.24 (DACK1)
/DACK2: J9.26 (~DACK2), RN2.8 (R7), U61.14 (DACK2), U64.4 (Rb)
/DACK3: J9.15 (~DACK3), RN2.9 (R8), U61.15 (DACK3), U64.5 (Ra)
/DEN: R105.1, U101.26 (DEN), U104.19 (CE)
/DRQ0: J10.12, RN3.4 (R3), SW2.4, U108.13 (OUT1)
/DRQ0_: R61.1, SW2.1, U61.19 (DREQ0)
/DRQ1: J9.18 (DRQ1), RN1.2 (R1), U61.18 (DREQ1)
/DRQ2: J9.6 (DRQ2), RN1.4 (R3), U61.17 (DREQ2)
/DRQ3: J9.16 (DRQ3), RN1.3 (R2), U61.16 (DREQ3)
/DTR: U101.27 (DT/~R~), U104.1 (A->B)
/E0000_CS: U202.22 (CE), U206.9 (O6)
/EOP: R62.1, U61.36 (~EOP~), U63.5
/FB1: U14.8 (~Q), U14.12 (D)
/FB2: U14.2 (D), U14.6 (~Q)
/HF_OSC: U14.9 (Q), U19.3 (XIN)
/HF_PCLK: J10.11, U14.5 (Q), U108.9 (CLK0), U108.15 (CLK1), U108.18 (CLK2)
/HOLD: J10.14, RN3.3 (R2), U61.10 (HRQ), U101.31 (HOLD)
/HOLDA: J10.13, U9.5 (E2), U61.7 (HLDA), U101.30 (HLDA), U102.1 (OE), U103.1 (OE), U105.15 (OE)
/INTA: U101.24 (~INTA~), U107.26 (~INTA~)
/INTR: U101.18 (INTR), U107.17 (INT)
/IN_IRQ6: CH376.10
/IORD: CH376.4, J9.14 (~IOR), RN2.5 (R4), U1.14 (A0), U19.9 (RD), U61.1 (~IOR~), U105.7 (Zb), U107.3 (~RD~), U108.22 (~RD~)
/IOWR: CH376.2, J9.13 (~IOW), RN2.4 (R3), U1.2 (A0), U19.11 (WR), U61.2 (~IOW~), U105.12 (Zc), U107.2 (~WR~), U108.23 (~WR~), U117.3 (A1)
/IO_00EX: CH376.6, U13.7 (O7)
/IO_000X: J10.2, U13.15 (O0), U61.11 (~CS~)
/IO_00XX: U12.15 (O0), U13.5 (E2)
/IO_0XXX: U9.15 (O0), U12.5 (E2)
/IO_002X: J10.3, U13.14 (O1), U107.1 (~CS~)
/IO_004X: J10.4, U13.13 (O2), U108.21 (~CS~)
/IO_006X: J10.5, U13.12 (O3), U17.15 (E)
/IO_008X: J10.6, U13.11 (O4), U117.2 (A0)
/IO_0060: U17.12 (O0), U19.7 (CS)
/IO_0061: U1.1 (E), U1.15 (E), U17.11 (O1)
/IO_M: U101.28 (IO/~M~), U105.1 (S)
/IRQ0: U107.18 (IR0), U108.10 (OUT0)
/IRQ1: J10.1, U19.39 (P24), U107.19 (IR1)
/IRQ2: J9.4 (IRQ2), U107.20 (IR2)
/IRQ3: J9.25 (IRQ3), U107.21 (IR3)
/IRQ4: J9.24 (IRQ4), U107.22 (IR4)
/IRQ5: J9.23 (IRQ5), U107.23 (IR5)
/IRQ6: J9.22 (IRQ6), U107.24 (IR6)
/IRQ7: J9.21 (IRQ7), U107.25 (IR7)
/KBD_CLK: U16.11, U19.41 (P26)
/KBD_CLK_INVERTED: U16.10, U20.1
/KBD_DATA: U19.42 (P27), U20.3
/LED_GND: D1.1 (K), R1.1
/MRD: J9.12 (~SMEMR), RN2.3 (R2), U61.3 (~MEMR~), U105.4 (Za), U201.24 (OE), U202.24 (OE), U203.24 (~OE), U204.24 (OE#)
/MWR: J9.11 (~SMEMW), RN2.2 (R1), U61.4 (~MEMW~), U105.9 (Zd), U202.31 (PGM), U203.29 (~WE), U204.29 (WE#)
/NC: J9.8 (UNUSED)
/NMI: J10.8, U16.4, U101.17 (NMI)
/NMI_EN: RN3.2 (R1), U2.16 (B2), U15.17 (Q2), U16.1
/NMI_EN_139: U16.2, U17.1 (E)
/NMI_INPUT: U16.3, U17.4 (O0)
/OSC: R3.2, R14.2, U11.12 (OSC)
/OSC88: J9.30 (OSC), R14.1
/OSC88HF: R3.1, U14.11 (C)
/PCLK: R17.2, U11.2 (PCLK)
/PCLK88: R17.1, U14.3 (C)
/PORT_0X61_CS: U15.11 (Load), U16.8
/PORT_0X61_EN: U1.4 (O0), U16.9
/PORT_61_2: U2.13 (B5), U15.14 (Q5)
/PORT_61_3: U2.14 (B4), U15.15 (Q4)
/PORT_61_4: U2.15 (B3), U15.16 (Q3)
/PORT_61_6: U2.17 (B1), U15.18 (Q1)
/PORT_61_7: U2.18 (B0), U15.19 (Q0)
/PORT_61_RD: U1.12 (O0), U2.19 (CE)
/POWER_GOOD: ATXPOWER1.8, R5.1
/POWER_ON: 8x8mm1.2 (B), ATXPOWER1.16, J6.1
/PU1: R104.1, U105.3 (I1a), U105.5 (I0b), U105.10 (I1d), U105.14 (I0c)
/RD: U101.32 (~RD~), U105.2 (I0a), U105.6 (I1b)
/RDY1: J9.41 (IO_READY), R6.2, U11.4 (RDY1), U106.4 (RDY1)
/READY: J10.15, U11.5 (READY), U61.6 (READY)
/READY1: U101.22 (READY), U106.5 (READY)
/REFRQ: J9.19 (~DACK0), RN2.6 (R5), SW2.3
/RESET: J10.16, J12.1, R5.2, SW1.1, U11.11 (~RES~), U19.5 (RESET), U106.11 (~RES~)
/RESET1: U101.21 (RESET), U106.10 (RESET)
/RESOUT: J9.2 (RESET), U11.10 (RESET), U61.13 (RESET)
/SPK_EN: U2.12 (B6), U15.13 (Q6), U16.5
/SPK_EN_: U16.6, U117.15 (E)
/SPK_GO: J10.10, U2.11 (B7), U15.12 (Q7), U108.16 (G2)
/SPK_OUT: J10.9, U108.17 (OUT2), U117.14 (A0)
/SPK_PIN: U3.2, U117.12 (O0)
/SPK_PIN_O: J3.1, U3.1
/T0: J2.5, R8.2, U19.2 (T0), U20.2
/T1: J2.1, R9.2, U19.43 (T1), U20.4
/TC: J9.27 (TC), R13.2, U63.6
/UPPER_512K: U205.5 (O1), U205.15 (E), U206.4 (E1)
/WR: U101.29 (WR), U105.11 (I0d), U105.13 (I1c)
/X1: R102.1, U106.17 (X1), Y101.2
/X1_8284: R4.1, U11.17 (X1), Y2.2
/X2: R103.1, U106.16 (X2), Y101.1
/X2_8284: R2.1, U11.16 (X2), Y2.1
GND: 8x8mm1.3 (C), ATXPOWER1.3, ATXPOWER1.5, ATXPOWER1.15, ATXPOWER1.18, ATXPOWER1.19, C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C22.1, C23.1, C24.1, C25.1, C26.1, C27.1, C28.1, C29.1, C63.1, C64.1, C65.1, C101.1, C102.1, C103.1, C104.1, C105.1, C106.1, C107.1, C108.1, C201.1, C202.1, C203.1, C204.1, C205.1, C206.1, CH376.14, CH376.16, J2.3, J3.3, J6.2, J9.1 (GND), J9.10 (GND), J9.31 (GND), J12.2, R1.2, R2.2, R4.2, R12.1, R13.1, R61.2, R102.2, R103.2, RN1.1 (common), RN3.1 (common), SW1.2, U1.3 (A1), U1.8 (GND), U1.13 (A1), U2.1 (A->B), U2.10 (GND), U9.8 (GND), U11.1 (CSYNC), U11.3 (~AEN1~), U11.6 (RDY2), U11.9 (GND)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
VCC: ATXPOWER1.4, ATXPOWER1.6, ATXPOWER1.21, C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C63.2, C64.2, C65.2, C101.2, C102.2, C103.2, C104.2, C105.2, C106.2, C107.2, C108.2, C201.2, C202.2, C203.2, C204.2, C205.2, C206.2, CH376.12, D1.2 (A), J2.4, J3.4, J9.3 (VCC), J9.29 (VCC), R6.1, R7.1, R8.1, R9.1, R62.2, R104.2, R105.2, RN2.1 (common), U1.16 (VCC), U2.20 (VCC), U9.6 (E3), U9.16 (VCC), U11.7 (~AEN2~), U11.18 (VCC), U12.6 (E3), U12.16 (VCC), U13.6 (E3), U13.16 (VCC), U14.1 (~R), U14.4 (~S), U14.10 (~S), U14.13 (~R), U14.14 (VCC), U15.20 (VCC), U16.14 (VCC), U17.16 (VCC), U19.38 (P17)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

Board: 2 copper layers, 170.2 x 243.8 mm, 114 parts (0 on the bottom side), 148 nets.

## KiCad design Kicad/Other PCBs/PPort/PPort.kicad_pcb

Parts:
C1, C2, C3, C4: 0.1uF; C_Disc_D4.3mm_W1.9mm_P5.00mm
J1: PORT C; PinHeader_2x05_P2.54mm_Vertical
J2: PORT B; PinHeader_2x05_P2.54mm_Vertical
J3: PORT A; PinHeader_2x05_P2.54mm_Vertical
J4: INTR B SELECT; PinHeader_2x06_P2.54mm_Vertical
J5: INTR A SELECT; PinHeader_2x06_P2.54mm_Vertical
J6: 8255 BASE PORT; PinHeader_2x08_P2.54mm_Vertical
J7: Bus_ISA_8bit; BUS_8_BIT
RN1, RN2, RN3, RN4, RN5, RN6: 4.7k OHM; R_Array_SIP5
U1: 8255; DIP-40_W15.24mm
U2, U3, U4: 74LS138; DIP-16_W7.62mm

Connections:
/5+: C1.2, C2.2, C3.2, C4.2, J1.1, J2.1, J3.1, J7.3 (VCC), J7.29 (VCC), U1.26 (VCC), U2.6 (E3), U2.16 (VCC), U3.6 (E3), U3.16 (VCC), U4.6 (E3), U4.16 (VCC)
/A0: J7.62 (BA00), U1.9 (A0)
/A1: J7.61 (BA01), U1.8 (A1)
/A2: J7.60 (BA02)
/A3: J7.59 (BA03)
/A4: J7.58 (BA04), U3.1 (A0)
/A5: J7.57 (BA05), U3.2 (A1)
/A6: J7.56 (BA06), U3.3 (A2)
/A7: J7.55 (BA07), U3.5 (E2)
/A8: J7.54 (BA08), U4.1 (A0)
/A9: J7.53 (BA09), U4.2 (A1)
/A10: J7.52 (BA10), U4.3 (A2)
/A11: J7.51 (BA11), U4.5 (E2)
/A12: J7.50 (BA12), U2.1 (A0)
/A13: J7.49 (BA13), U2.2 (A1)
/A14: J7.48 (BA14), U2.3 (A2)
/A15: J7.47 (BA15), U2.5 (E2)
/CS8255: J6.1, J6.3, J6.5, J6.7, J6.9, J6.11, J6.13, J6.15, U1.6 (~CS~)
/D0: J7.40 (DB0), U1.34 (D0)
/D1: J7.39 (DB1), U1.33 (D1)
/D2: J7.38 (DB2), U1.32 (D2)
/D3: J7.37 (DB3), U1.31 (D3)
/D4: J7.36 (DB4), U1.30 (D4)
/D5: J7.35 (DB5), U1.29 (D5)
/D6: J7.34 (DB6), U1.28 (D6)
/D7: J7.33 (DB7), U1.27 (D7)
/GND: C1.1, C2.1, C3.1, C4.1, J1.2, J2.2, J3.2, J7.1 (GND), J7.31 (GND), RN1.1 (common), RN2.1 (common), RN3.1 (common), RN4.1 (common), RN5.1 (common), RN6.1 (common), U1.7 (GND), U2.4 (E1), U2.8 (GND), U3.8 (GND), U4.8 (GND); also elsewhere on the board
/IOR: J7.14 (~IOR), U1.5 (~RD~)
/IOW: J7.13 (~IOW), U1.36 (~WR~)
/IO_0XXX: U2.15 (O0), U4.4 (E1)
/IO_04XX: U3.4 (E1), U4.11 (O4)
/IO_040X: J6.2, U3.15 (O0)
/IO_041X: J6.4, U3.14 (O1)
/IO_042X: J6.6, U3.13 (O2)
/IO_043X: J6.8, U3.12 (O3)
/IO_044X: J6.10, U3.11 (O4)
/IO_045X: J6.12, U3.10 (O5)
/IO_046X: J6.14, U3.9 (O6)
/IO_047X: J6.16, U3.7 (O7)
/IRQ2: J4.12, J5.12, J7.4 (IRQ2)
/IRQ3: J4.10, J5.10, J7.25 (IRQ3)
/IRQ4: J4.8, J5.8, J7.24 (IRQ4)
/IRQ5: J4.6, J5.6, J7.23 (IRQ5)
/IRQ6: J4.4, J5.4, J7.22 (IRQ6)
/IRQ7: J4.2, J5.2, J7.21 (IRQ7)
/PA0: J3.10, RN6.5 (R4), U1.4 (PA0)
/PA1: J3.8, RN6.4 (R3), U1.3 (PA1)
/PA2: J3.6, RN6.3 (R2), U1.2 (PA2)
/PA3: J3.4, RN6.2 (R1), U1.1 (PA3)
/PA4: J3.9, RN5.5 (R4), U1.40 (PA4)
/PA5: J3.7, RN5.4 (R3), U1.39 (PA5)
/PA6: J3.5, RN5.3 (R2), U1.38 (PA6)
/PA7: J3.3, RN5.2 (R1), U1.37 (PA7)
/PB0: J2.10, RN4.5 (R4), U1.18 (PB0)
/PB1: J2.8, RN4.4 (R3), U1.19 (PB1)
/PB2: J2.6, RN4.3 (R2), U1.20 (PB2)
/PB3: J2.4, RN4.2 (R1), U1.21 (PB3)
/PB4: J2.9, RN2.5 (R4), U1.22 (PB4)
/PB5: J2.7, RN2.4 (R3), U1.23 (PB5)
/PB6: J2.5, RN2.3 (R2), U1.24 (PB6)
/PB7: J2.3, RN2.2 (R1), U1.25 (PB7)
/PC0: J1.10, J4.1, J4.3, J4.5, J4.7, J4.9, J4.11, RN3.5 (R4), U1.14 (PC0)
/PC1: J1.8, RN3.4 (R3), U1.15 (PC1)
/PC2: J1.6, RN3.3 (R2), U1.16 (PC2)
/PC3: J1.4, J5.1, J5.3, J5.5, J5.7, J5.9, J5.11, RN3.2 (R1), U1.17 (PC3)
/PC4: J1.9, RN1.5 (R4), U1.13 (PC4)
/PC5: J1.7, RN1.4 (R3), U1.12 (PC5)
/PC6: J1.5, RN1.3 (R2), U1.11 (PC6)
/PC7: J1.3, RN1.2 (R1), U1.10 (PC7)
/RST: J7.2 (RESET), U1.35 (RESET)

Board: 2 copper layers, 104.0 x 73.9 mm, 23 parts (0 on the bottom side), 68 nets.

Other parts of the board:
R: L; Large_Via
R#2: L; Large_Via

Their connections:
/GND: R.1; also elsewhere on the board

## KiCad design Kicad/Other PCBs/Breadboard Adapter/Breadboard Adapter.kicad_pcb

Board: 2 copper layers, 20.6 x 137.2 mm, 11 parts (4 on the bottom side), 76 nets.

Parts:
C1: 4.7uF; CP_Radial_D4.0mm_P1.50mm
J1: Conn_02x08_Counter_Clockwise; 2x08_PIN_EDGE_CARD
J2: USB_C_Receptacle_USB2.0; USB_C_Receptacle_GCT_USB4085
J3, J4: Conn_01x31; PinHeader_1x31_P2.54mm_Vertical
J5, J6: Conn_01x8; PinHeader_1x08_P2.54mm_Vertical
J9: Bus_ISA_8bit; 8-bit-ISA
RN1: 10K ohm; R_Array_SIP9
RN2: 10K ohm; R_Array_SIP4
SW1: SW_Push_DPDT; 6 PIN DTDP

Connections:
/5+: J3.3, J3.29, J9.3, J9.29, RN1.1, SW1.2
/5-: J3.5, J9.5
/12+: J3.9, J9.9
/12-: J3.7, J9.7
/A0: J4.31, J9.62
/A1: J4.30, J9.61
/A2: J4.29, J9.60
/A3: J4.28, J9.59
/A4: J4.27, J9.58
/A5: J4.26, J9.57
/A6: J4.25, J9.56
/A7: J4.24, J9.55
/A8: J4.23, J9.54
/A9: J4.22, J9.53
/A10: J4.21, J9.52
/A11: J4.20, J9.51
/A12: J4.19, J9.50
/A13: J4.18, J9.49
/A14: J4.17, J9.48
/A15: J4.16, J9.47
/A16: J4.15, J9.46
/A17: J4.14, J9.45
/A18: J4.13, J9.44
/A19: J4.12, J9.43
/AEN: J4.11, J9.42
/ALE: J3.28, J9.28
/CH_CK: J4.1, J9.32
/CLK88: J3.20, J9.20
/D0: J4.9, J9.40
/D1: J4.8, J9.39
/D2: J4.7, J9.38
/D3: J4.6, J9.37
/D4: J4.5, J9.36
/D5: J4.4, J9.35
/D6: J4.3, J9.34
/D7: J4.2, J9.33
/DACK1: J3.17, J9.17
/DACK2: J3.26, J9.26
/DACK3: J3.15, J9.15
/DRQ0: J1.12, J6.5
/DRQ1: J3.18, J9.18
/DRQ2: J3.6, J9.6
/DRQ3: J3.16, J9.16
/GND: C1.2, J2.A1, J2.A12, J2.B1, J2.B12, J3.1, J3.10, J3.31, J9.1, J9.10, J9.31, RN2.1
/HF_PCLK: J1.11, J6.6
/HOLD: J1.14, J6.3, RN2.4
/HOLDA: J1.13, J6.4
/IORD: J3.14, J9.14, RN1.7
/IOWR: J3.13, J9.13, RN1.6
/IO_000X: J1.2, J5.2
/IO_002X: J1.3, J5.3
/IO_004X: J1.4, J5.4
/IO_006X: J1.5, J5.5
/IO_008X: J1.6, J5.6
/IRQ1: J1.1, J5.1
/IRQ2: J3.4, J9.4
/IRQ3: J3.25, J9.25
/IRQ4: J3.24, J9.24
/IRQ5: J3.23, J9.23
/IRQ6: J3.22, J9.22
/IRQ7: J3.21, J9.21
/MRD: J3.12, J9.12, RN1.5
/MWR: J3.11, J9.11, RN1.4
/NC: J3.8, J9.8
/NMI: J1.8, J5.8, RN2.2
/OSC88: J3.30, J9.30
/PIN7: J1.7, J5.7
/POWER_SUPPLY: J2.A4, J2.A9, J2.B4, J2.B9, SW1.3
/RDY1: J4.10, J9.41, RN1.8
/READY: J1.15, J6.2
/REFRQ: J3.19, J9.19
/RESET: C1.1, J1.16, J6.1, RN1.9
/RESOUT: J3.2, J9.2
/SPK_GO: J1.10, J6.7
/SPK_OUT: J1.9, J6.8
/TC: J3.27, J9.27

## KiCad design Kicad/Other PCBs/640K ISA/640k.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6: 0.1uF; C_Disc_D4.3mm_W1.9mm_P5.00mm
J9: Bus_ISA_8bit; BUS_8_BIT
U1: 28C256; DIP-28_W15.24mm
U2: 62256; DIP-28_W15.24mm
U3: AS6C1008; DIP-32_W15.24mm
U4: AS6C4008; DIP-32_W15.24mm
U5: 74LS139; DIP-16_W7.62mm
U6: 74LS138; DIP-16_W7.62mm

Connections:
/5+: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, J9.3 (VCC), J9.29 (VCC), U1.27 (~WE), U1.28 (VCC), U2.28 (VCC), U3.30, U3.32, U4.32 (VCC), U5.16 (VCC), U6.16 (VCC)
/5-: J9.5 (-5V)
/12+: J9.9 (+12V)
/12-: J9.7 (-12V)
/32K_RAM_CS: U2.20 (~CS), U6.9 (O6)
/32K_ROM_CS: U1.20 (~CS), U6.7 (O7)
/128K_CS: U3.22, U5.12 (O0)
/512K_CS: U4.22 (CE#), U5.4 (O0)
/A0: J9.62 (BA00), U1.10 (A0), U2.10 (A0), U3.12, U4.12 (A0)
/A1: J9.61 (BA01), U1.9 (A1), U2.9 (A1), U3.11, U4.11 (A1)
/A2: J9.60 (BA02), U1.8 (A2), U2.8 (A2), U3.10, U4.10 (A2)
/A3: J9.59 (BA03), U1.7 (A3), U2.7 (A3), U3.9, U4.9 (A3)
/A4: J9.58 (BA04), U1.6 (A4), U2.6 (A4), U3.8, U4.8 (A4)
/A5: J9.57 (BA05), U1.5 (A5), U2.5 (A5), U3.7, U4.7 (A5)
/A6: J9.56 (BA06), U1.4 (A6), U2.4 (A6), U3.6, U4.6 (A6)
/A7: J9.55 (BA07), U1.3 (A7), U2.3 (A7), U3.5, U4.5 (A7)
/A8: J9.54 (BA08), U1.25 (A8), U2.25 (A8), U3.27, U4.27 (A8)
/A9: J9.53 (BA09), U1.24 (A9), U2.24 (A9), U3.26, U4.26 (A9)
/A10: J9.52 (BA10), U1.21 (A10), U2.21 (A10), U3.23, U4.23 (A10)
/A11: J9.51 (BA11), U1.23 (A11), U2.23 (A11), U3.25, U4.25 (A11)
/A12: J9.50 (BA12), U1.2 (A12), U2.2 (A12), U3.4, U4.4 (A12)
/A13: J9.49 (BA13), U1.26 (A13), U2.26 (A13), U3.28, U4.28 (A13)
/A14: J9.48 (BA14), U1.1 (A14), U2.1 (A14), U3.3, U4.3 (A14)
/A15: J9.47 (BA15), U3.31, U4.31 (A15), U6.1 (A0)
/A16: J9.46 (BA16), U3.2, U4.2 (A16), U6.2 (A1)
/A17: J9.45 (BA17), U4.30 (A17), U5.14 (A0), U6.3 (A2)
/A18: J9.44 (BA18), U4.1 (A18), U5.13 (A1), U6.6 (E3)
/A19: J9.43 (BA19), U5.2 (A0)
/AEN: J9.42 (AEN)
/ALE: J9.28 (ALE)
/CH_CK: J9.32 (IO)
/CLK88: J9.20 (CLK)
/D0: J9.40 (DB0), U1.11 (D0), U2.11 (D0), U3.13, U4.13 (DQ0)
/D1: J9.39 (DB1), U1.12 (D1), U2.12 (D1), U3.14, U4.14 (DQ1)
/D2: J9.38 (DB2), U1.13 (D2), U2.13 (D2), U3.15, U4.15 (DQ2)
/D3: J9.37 (DB3), U1.15 (D3), U2.15 (D3), U3.17, U4.17 (DQ3)
/D4: J9.36 (DB4), U1.16 (D4), U2.16 (D4), U3.18, U4.18 (DQ4)
/D5: J9.35 (DB5), U1.17 (D5), U2.17 (D5), U3.19, U4.19 (DQ5)
/D6: J9.34 (DB6), U1.18 (D6), U2.18 (D6), U3.20, U4.20 (DQ6)
/D7: J9.33 (DB7), U1.19 (D7), U2.19 (D7), U3.21, U4.21 (DQ7)
/DACK1: J9.17 (~DACK1)
/DACK2: J9.26 (~DACK2)
/DACK3: J9.15 (~DACK3)
/DRQ1: J9.18 (DRQ1)
/DRQ2: J9.6 (DRQ2)
/DRQ3: J9.16 (DRQ3)
/GND: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, J9.1 (GND), J9.10 (GND), J9.31 (GND), U1.14 (GND), U2.14 (GND), U3.16, U4.16 (VSS), U5.1 (E), U5.3 (A1), U5.8 (GND), U6.5 (E2), U6.8 (GND); also elsewhere on the board
/IORD: J9.14 (~IOR)
/IOWR: J9.13 (~IOW)
/IRQ2: J9.4 (IRQ2)
/IRQ3: J9.25 (IRQ3)
/IRQ4: J9.24 (IRQ4)
/IRQ5: J9.23 (IRQ5)
/IRQ6: J9.22 (IRQ6)
/IRQ7: J9.21 (IRQ7)
/MRD: J9.12 (~SMEMR), U1.22 (~OE), U2.22 (~OE), U3.24, U4.24 (OE#)
/MWR: J9.11 (~SMEMW), U2.27 (~WE), U3.29, U4.29 (WE#)
/NC: J9.8 (UNUSED)
/OSC88: J9.30 (OSC)
/RDY1: J9.41 (IO_READY)
/REFRQ: J9.19 (~DACK0)
/RESOUT: J9.2 (RESET)
/TC: J9.27 (TC)
/UPPER_512K: U5.5 (O1), U5.15 (E), U6.4 (E1)

Board: 2 copper layers, 104.0 x 73.9 mm, 15 parts (0 on the bottom side), 37 nets.

Other parts of the board:
R: L; Large_Via
R#2: L; Large_Via

Their connections:
/GND: R.1; also elsewhere on the board

Notices in the files:
Kicad/8088 ATX/8088 ATX.kicad_pcb:
Copyright (C) 2023 EMM
Kicad/Other PCBs/640K ISA/640k.kicad_pcb:
Copyright (C) 2022 EMM
